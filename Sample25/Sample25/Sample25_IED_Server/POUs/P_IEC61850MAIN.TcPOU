PROGRAM P_IEC61850MAIN
VAR
END_VAR

fbMyClock.Execute();
fbIEDServer.Execute();
fbIEDServerSession1();

(*
fbIEDServerSession2();
...
fbIEDServerSessionN();
*)

END_PROGRAM
